# Keil uVision project project.uvprojx, settings and files
target ACM32F4XX (6150000::V6.15::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ACM32F4XX +hex
  AfterMake: fromelf.exe --bin --output ./build/ACM32F4.bin ./build/ACM32F4.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\HAL_Driver\Inc;libraries\Device;libraries\CMSIS;applications;.;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\extension;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m33;..\..\components\drivers\audio;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\io\stdio;..\..\components\libc\posix\ipc;..\..\components\drivers\usb\usbdevice;.\packages\iso15765p2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_UART.c HAL_TIMER.c HAL_FSUSB.c HAL_CAN.c HAL_RTC.c HAL_EXTI.c HAL_DMA.c HAL_ADC.c HAL_I2C.c HAL_DAC.c HAL_WDT.c HAL_SPI.c HAL_IWDT.c HAL_GPIO.c HAL_EFlash.c HAL_EFlash_EX.lib
    libraries/Device/: Startup_ACM32F4.s System_ACM32F4.c System_Accelerate.lib
  group Applications
    applications/: alarm_sample.c hwtimer_sample.c main.c wdt_sample.c spi_sample.c i2c_sample.c
    ./applications/: can_sample.c iso15765_sample.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../libcpu/arm/cortex-m33/: syscall_rvds.S cpuport.c trustzone.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/audio/: audio_pipe.c audio.c
    ../../components/drivers/can/: can.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/ipc/: workqueue.c pipe.c ringblk_buf.c waitqueue.c completion.c ringbuffer.c dataqueue.c
    ../../components/drivers/misc/: dac.c adc.c rt_drv_pwm.c pin.c
    ../../components/drivers/rtc/: rtc.c alarm.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/watchdog/: watchdog.c
  group Drivers
    drivers/: drv_gpio.c drv_can.c drv_dac.c drv_wdt.c board.c drv_pin_table.c drv_spi.c drv_hwtimer.c drv_rtc.c drv_uart.c drv_usbd.c drv_i2c.c drv_adc.c drv_pwm.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: device.c ipc.c kservice.c thread.c clock.c scheduler.c components.c timer.c irq.c mempool.c mem.c object.c idle.c
  group rt_usbd
    ../../components/drivers/usb/usbdevice/class/: winusb.c
    ../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group iso15765
    ./packages/iso15765p2/: lib_iqueue.c lib_iso15765.c
